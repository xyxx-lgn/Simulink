# Keil uVision project FOC_FD6288Q_V1.uvprojx, settings and files
target FOC_FD6288Q_V1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.2.1
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FOC_FD6288Q_V1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;./Hardware;./Software;./Hardware/MT6701;./Hardware/Motor;./Software/Start;./Software/FOC;./Software/PID;./Software/Test;./Hardware/My_Cordic;./Hardware/My_Can;./Hardware/Filter;.\Model\PMSM_MC_2025a_ert_rtw
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c cordic.c dma.c fdcan.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Software
    ./Software/Start/: Start.c Start.h
    ./Software/FOC/: FOC.c FOC.h
    ./Software/PID/: PID.c PID.h
    ./Software/Test/: Test.c Test.h
  group Hardware
    ./Hardware/: ALL_H.h
    ./Hardware/MT6701/: MT6701.c MT6701.h
    ./Hardware/Motor/: Motor.c Motor.h
    ./Hardware/My_Cordic/: My_Cordic.c My_Cordic.h
    ./Hardware/Filter/: Filter.c Filter.h
    ./Hardware/My_Can/: My_Can.c My_Can.h
  group Model
    ./Model/PMSM_MC_2025a_ert_rtw/: PMSM_MC_2025a.c PMSM_MC_2025a.h PMSM_MC_2025a_data.c rt_nonfinite.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_cordic.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.6.0
